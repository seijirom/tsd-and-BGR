* H:\DESKTOP\ËY¼0SS0\4810\TEST3.ASC
*

M23 A VBGR N008 VIN PMOS L=1U W=20U
R6 A 0 20K
M29 B VBGR N005 VIN PMOS L=1U W=20U
M12 B B B 0 PMOS L=1U W=20U
M33 N009 VBGR N003 VIN PMOS L=1U W=20U
M14 N012 B N009 N009 PMOS L=1U W=20U
M15 N011 A N009 N009 PMOS L=1U W=20U
M16 N011 N012 0 0 NMOS L=1U W=20U
M17 N012 N012 0 0 NMOS L=1U W=20U
M37 N010 VBGR N001 VIN PMOS L=1U W=20U
M19 N010 N011 0 0 NMOS L=1U W=20U
M20 TMS N010 0 0 NMOS L=1U W=20U
M21 N013 N011 0 0 NMOS L=1U W=100U
R8 VIN TMS 100K
M22 N008 VBGR VIN VIN PMOS L=1U W=20U
M28 N005 VBGR VIN VIN PMOS L=1U W=20U
M32 N003 VBGR VIN VIN PMOS L=1U W=20U
M36 N001 VBGR VIN VIN PMOS L=1U W=20U
M35 N010 VBGR N002 VIN PMOS L=1U W=20U
M34 N002 VBGR VIN VIN PMOS L=1U W=20U
M31 N009 VBGR N004 VIN PMOS L=1U W=20U
M30 N004 VBGR VIN VIN PMOS L=1U W=20U
M27 B VBGR N006 VIN PMOS L=1U W=20U
M26 N006 VBGR VIN VIN PMOS L=1U W=20U
M25 A VBGR N007 VIN PMOS L=1U W=20U
M24 N007 VBGR VIN VIN PMOS L=1U W=20U
R7 A N013 100K
*.INCLUDE "./MODELS/OR1_MOS"
